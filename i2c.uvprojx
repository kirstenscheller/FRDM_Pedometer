# Keil uVision project i2c.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2c
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK64FN1M0VLL12
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./src/: 3140_accel.c 3140_i2c.c 3140_i2c.h 3140_serial.c 3140_serial.h 3140_accel.h 3140.s 3140_concur.c 3140_concur.h lab3_t0.c utils.c shared_structs.h utils.h process.c accel_t1.c accel_level.c pedometer_noSW.c pedometer_wSW.c simple_switch.c pedometer_parameters.h
software components: CMSIS Driver:I2C:Custom 2.3.0, CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:CMSIS:MK64F12_header 1.0.0, Device:SDK Drivers:clock 2.5.1, Device:SDK Drivers:common 2.2.2, Device:SDK Drivers:gpio 2.4.1, Device:SDK Drivers:i2c 2.0.8, Device:SDK Drivers:port 2.1.0
